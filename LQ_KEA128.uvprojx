# Keil uVision project LQ_KEA128.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LQ_KEA128
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TRK_KEA128,CPU_KEA128,IAR
  c include: .\common;.\cpu;.\drivers;.\user;.\RTE\Device\Include;.\RAbuild
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group User
    ./user/: 8700_2100.c isr.c LQ12864.c LQKEY.c LQLED.c main.c MPU6050.c MPUIIC.c Serial_oscilloscope.c include.h
  group drivers
    ./drivers/: adc.c crc.c ftm.c gpio.c i2c.c kbi.c mscan.c pit.c pmc.c pwt.c rtc.c spi.c uart.c wdog.c systick.c
  group cpu
    ./cpu/: arm_cm0.c
  group commin
    ./common/: assert.c
  group CMSIS
    ./RTE/Device/SKEAZ128xxx4/: startup_SKEAZ1284.s
    ./cpu/: system_SKEAZ1284.c
  group RAbuild
    ./RAbuild/: deal.c deal.h getsig.c getsig.h Motor.c Motor.h System.c System.h spit.c spit.h bt.c bt.h
    ./: readme.txt
